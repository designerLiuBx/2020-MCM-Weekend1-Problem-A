# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\liu_drivers\BEEP;..\liu_drivers\KEY;..\liu_drivers\LCD;..\liu_drivers\LED;..\liu_drivers\PWM;..\liu_drivers\TIMER;..\liu_general;..\liu_drivers\GY953;..\liu_drivers\SPI;..\liu_algorithm;..\liu_algorithm\PID;..\liu_algorithm\CONTROL;..\USMART;..\SYSTEM\usart2;..\SYSTEM\usart3;..\liu_drivers\W25QXX;..\liu_drivers\SPI;..\liu_drivers\china;..\SYSTEM\uart5;..\liu_drivers\STM32_up
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group liu_algorithm
    ../liu_algorithm/: ALG_dsp.c
    ../liu_algorithm/PID/: ALG_pid.c
    ../liu_algorithm/CONTROL/: ALG_control.c
  group liu_general
    ../liu_general/: All_Init.c Gen_Scheduler.c Gen_structconfig.c Gen_Structconfig.h Gen_include.h
  group liu_drivers
    ../liu_drivers/BEEP/: Drv_beep.c
    ../liu_drivers/TIMER/: Drv_timer.c
    ../liu_drivers/KEY/: Drv_key.c
    ../liu_drivers/LCD/: Drv_lcd.c
    ../liu_drivers/LED/: Drv_led.c
    ../liu_drivers/PWM/: Drv_pwm.c
    ../liu_drivers/GY953/: Sen_gy953.c
    ../liu_drivers/china/: lcd_hz.c
    ../liu_drivers/SPI/: spi.c
    ../liu_drivers/W25QXX/: w25qxx.c
    ../liu_drivers/STM32_up/: DataScope_DP.C
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart2/: usart2.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/usart3/: usart3.c usart3_it.c
    ../SYSTEM/uart5/: usart5.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: readme.txt
